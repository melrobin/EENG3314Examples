* This is Practice Problem 14.16 p655

I1 0 1 AC 1
L1 1 0 0.4m
C1 1 0 1u
R1 1 0 1K
